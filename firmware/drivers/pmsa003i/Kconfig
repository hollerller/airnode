## firmware/drivers/pmsa003i/Kconfig
```kconfig
config PMSA003I 
    bool "Activate PMSA003I driver"
    default n  		
    depends on I2C 
```
